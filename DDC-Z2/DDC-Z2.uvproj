# Keil uVision project DDC-Z2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: DDC-Z2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 AD.c PWM.c voice.c Main.c Delay.c communication.c Battery.c Other.c Timer.c operation.c UART.c
